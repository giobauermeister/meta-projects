FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-change-dts-enable-fusion-display.patch"
SRC_URI += "file://0001-modified-dts-for-fusion-7-on-apalis.patch"
